# Keil uVision project blinky.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ESEL ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51422
  c include: ..\..\core\include;..\..\core\include\cmsis;..\..\core\include\mcu
  asm define: NRF51422
  asm misc: --cpreproc_opts=-DNRF51422
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c
    ../../core/mcu/: system_nrf51.c
    ../../core/error/: nrf_assert.c nrf_error.c nrf_fault.c
    ../../core/mcu/arm/: arm_startup_nrf51.S arm_startup_nrf51.S

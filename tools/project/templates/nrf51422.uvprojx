# Keil uVision project nrf51422.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ESEL ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: {%- for define in defines %}{{ define }}{%- endfor %}
  c include: {%- for include in includes %}{%- if loop.first %}{{ include }}{% else %};{{ include }}{%- endif %}{%- endfor %}
  asm define: {%- for define in defines %}{{ define }}{%- endfor %}
  asm misc: {% if "defines" %}--cpreproc_opts={%- for define in defines %}-D{{ define }}{%if not loop.last %},{% endif %}{%- endfor %}{% endif %}
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: {{ file.path }}
